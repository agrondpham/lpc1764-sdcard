# Keil uVision project FAT_font_program.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Source\Lcd;..\Source\SPI;..\Source\FAT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup code
    ../LPC17xx/: startup_LPC17xx.s system_LPC17xx.c
  group User
    ../Source/User/: main.c
  group Lcd
    ../Source/Lcd/: Lcd.c
  group Documentation
    ../: Readme.txt
  group SPI
    ../Source/SPI/: delay.c SSP0.C SPI.C
  group FAT
    ../Source/SPI/: FAT.C text.c fontupd.c
    ../Source/FAT/: jpegdecode.c untogb.c
  group SD
    ../Source/SPI/: MMC_SD.C
  group Fatfs
    ../Source/Fatfs/: ff.c
  group Uart
    ../Source/uart/: uart.c
