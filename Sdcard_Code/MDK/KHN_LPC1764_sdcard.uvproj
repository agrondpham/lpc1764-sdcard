# Keil uVision project KHN_LPC1764_sdcard.uvproj, settings and files
target KHN_LPC1764_Sdcard (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: khn_lpc1764_sdcard +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Source\Lcd;..\Source\SPI;..\Source\FAT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup code
    ../LPC17xx/: system_LPC17xx.c startup_LPC17xx.s
  group User
    ../Source/User/: main.c
  group Lcd
    ../Source/Lcd/: Lcd.c
  group SPI
    ../Source/SPI/: delay.c SPI.C
  group SD
    ../Source/SPI/: MMC_SD.C
  group Fatfs
    ../Source/Fatfs/: ff.c
  group Uart
    ../Source/uart/: uart.c
