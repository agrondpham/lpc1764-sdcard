# Keil uVision project KHN_LPC1764_sdcard.uvproj, settings and files
target KHN_LPC1764_Sdcard (ARM-ADS)
  device: LPC1764 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IRAM2(0x2007C000-0x2007FFFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: khn_lpc1764_sdcard +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Source\Lcd;..\Source\sdcard;..\Source\sdcard\Fatfs;..\Source\uart
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Startup code
    ../LPC17xx/: system_LPC17xx.c startup_LPC17xx.s
  group User
    ../Source/User/: main.c delay.c
  group Lcd
    ../Source/Lcd/: Lcd.c
  group Uart
    ../Source/uart/: uart.c
  group Sdcard
    ../Source/sdcard/Fatfs/: ff.c
    ../Source/sdcard/: sd.c spi.c
